# Keil uVision project BalanceLQR.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: BalanceLQR
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: balanceLQR.c balanceLQR_data.c main.c misc.c pulsetoangle_wrapper.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c system_stm32f4xx.c waijung_hwdrvlib.c startup_stm32f4xx.s pulsetoangle1_wrapper.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4_io_customcode.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
